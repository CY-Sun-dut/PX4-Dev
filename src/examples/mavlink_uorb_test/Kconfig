## src/examples/mavlink_uorb_test/Kconfig
```kconfig
menuconfig EXAMPLES_MAVLINK_UORB_TEST
	bool "mavlink_uorb_test"
	default n
	---help---
		Enable support for mavlink_uorb_test
```
